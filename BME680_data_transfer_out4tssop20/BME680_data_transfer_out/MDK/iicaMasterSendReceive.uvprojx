# Keil uVision project iicaMasterSendReceive.uvprojx, settings and files
target CMS32L051 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMS32L051TS20 Cmsemicon
  pack: Cmsemicon.CMS32L051.1.2.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: bme680V1.0.2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ./src/: libalgobsec.lib
    ./: main.c
  group Driver
    ./src/: bme680.c retarget.c sci.c sci_user.c bsec_integration.c common_porting.c gpio.c intp.c Sim_I2C_Slave.c wdt.c wdt_user.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
